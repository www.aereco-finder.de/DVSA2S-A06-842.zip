Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DVSA2S-A06_2x3.IFC
Time: 2021-10-29T08:52:37
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10400.00055.0161A_M3 x 6 (2)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Linsenschraube DIN 7985; Bezeichnung2: ISO 7045 - M3 x 6 - Z --- 6C; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 25.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.03015.0022A_Enddeckel (2)
In: Default Storey
SolidWorks Custom Properties - Material: RAF-SE (50); Dicke: "Dicke@Blech1"; Weight: 0.049; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.0223G (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.694; Bezeichnung: Vertikalblech; Bezeichnung2: DVV 05/10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.0225C (3)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: 1.0226 (DX51D); Dicke: 1.5; Weight: 0.010; Bezeichnung: Distanzblech; Surface: verzinkt; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.0616D
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,25; Weight: 0.150; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.0623C
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1; Weight: 1.314; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.0624E
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1; Weight: 0.593; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.0630A (4)
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 0.065; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1205C
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.5486397572233964; Bezeichnung: Ventilatortragblech; Bezeichnung2: Schrägdachsockel DVV0; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1215B
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 0.925; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1279B
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 3.207; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1280C
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 3.212; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1281B
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 0.795; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1284B
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1; Weight: 1.007; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1291A (3)
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 3; Weight: 0.420; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
2 x DVSA2S-A06_00200.90100.1291A
DVSA2S-A06_00200.90100.1291A | Material: 3.3535 (EN-AW 5754)

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1292A (2)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: "Dicke@Blech1"; Weight: 0.212; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1293A
In: Default Storey
SolidWorks Custom Properties - Description: Rohrverbinder für Rohranschluss-Stutzen DN200; Material: 1.0226 (DX51D); Dicke: "Dicke@Blech1"; Weight: 0.529; surface: -; Bezeichnung: Rohrverbinder; Bezeichnung2: DN 200; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1295A
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 3; Weight: 0.356; Bezeichnung: Montagering; Bezeichnung2: Klemmring; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1296A
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: "Dicke@Blech1"; Weight: 0.219; Bezeichnung: Rohrhülse; Bezeichnung2: Klemmring, Innen-Ø: 310mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1369A (3)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: 3.3535 (EN-AW 5754); Dicke: 3; Weight: 0.015; Bezeichnung: Verschlusswinkel SW9; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1370A (3)
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 2; Weight: 0.008; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1371A
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 2; Weight: 0.022; Bezeichnung: Verschlusswinkel; Bezeichnung2: Durchgangsloch ø 4.9 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.1372A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: 3.3535 (EN-AW 5754); Dicke: 3; Weight: 0.016; Bezeichnung: Verschlusswinkel SW9; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.2039B
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.103; Bezeichnung: Abdeck- und Griffschutzblech; Bezeichnung2: mit Schalterschutz; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.2048D
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.689; Bezeichnung: Vertikalblech DVV05/10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.2689A
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.680; Bezeichnung: Vertikalblech DVV05/10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.2700A
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,25; Weight: 1.413; Bezeichnung: Ventilator-Grundrahmen; Bezeichnung2: DV06/ DVA10; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.2725A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: 1.0226 (DX51D); Dicke: 1; Weight: 0.094; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.90100.2762A
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 0.084; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.95000.0087A_Typenschild DV-A06
In: Default Storey
SolidWorks Custom Properties - Material: XAC 33; Dicke: "Dicke@Blech1"; Weight: 0.08; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.95400.0001A_Warnhinweis
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 2.44; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00200.95400.0014A (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: 0,20; Weight: 0.000; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_00700.95400.0012A (2)
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVSA2S-A06_00700.95400.0012A | Material: Hochdichte PE-Folie
DVSA2S-A06_00700.95400.0012A

# IfcBuildingElementProxy: DVSA2S-A06_10200.00100.0087A_1
In: Default Storey
SolidWorks Custom Properties - Material: Kupfer; Dicke: "Dicke@Blech1"; Weight: 0.013; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.00100.0087A_2_DV A05-10
In: Default Storey
SolidWorks Custom Properties - Material: Kupfer; Dicke: "Dicke@Blech1"; Weight: 0.012; Bezeichnung: Erdungsband 4mm²; Bezeichnung2: Lochmittenabstand 90mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.00200.0009A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.008; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.00200.0010A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.008; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.08000.0040A_1_Default
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.016; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.08000.0040A_2_Default
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.012; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.08000.0040A_3
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.08000.0040A_4
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.001; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.08000.0051A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.08000.0054A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: PE niedrige/mittlere Dichte; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.08000.0059A (3)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: PA Typ 6; Dicke: "Dicke@Blech"; Weight: 0.011; Zuschnittlänge: 1; Zuschnittbreite: 1; Nomenclature: 50.620 PA7001; Part Number: 50.620 PA7001; Source: NOT_KNOWN; Revision: ANY; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10200.09000.0030A (4)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.000; Zuschnittlänge: 1; Zuschnittbreite: 1; Beschreibung: Sicherungsscheibe; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00030.0018A_Default (4)
In: Default Storey
SolidWorks Custom Properties - DESIGN: KS Klemmscheibe für Wellen ohne Nut; REFERENCE: KS 5; SUPPLIER: SEEGER-ORBIS; TYPE: CATPART; Material: Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Klemmscheibe M6; Bezeichnung2: DIN 99107-6; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00030.0025A
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: Stahl; OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00030.0032A (4)
In: Default Storey
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: 1.0226 (DX51D); OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name | Material
3 x DVSA2S-A06_10400.00030.0032A | 1.0226 (DX51D)
DVSA2S-A06_10400.00030.0032A

# IfcBuildingElementProxy: DVSA2S-A06_10400.00055.0172A
In: Default Storey
Material: Stahl
SolidWorks Custom Properties - NN: DIN 913 (ISO 4026) - A2; NT: Hexagon socket set screws with flat point; NB: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; NBSYN: WUERTH $ARTNR. headless screw DIN 913 $NENN. $GUETE. $OBERFLAECHE.; LINA: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; ROWDESC: M8x40; ARTNR: 02618 40; MATERIAL: Stahl; GUETE: VORDEF; OBERFLAECHE: BLK; D: 8.000; D3: 6.466; P: 1.250; L: 40.000; DP: 5.500; S: 4.000; T: 5.000; SUPPLIER: WUERTH; ARTICLENO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; BOMINFO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.015; Bezeichnung: Gewindestift ISO 4026; Bezeichnung2: M8 x 40 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00055.0173A_Default (4)
In: Default Storey
SolidWorks Custom Properties - A: 2.400; ARTICLENO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; ARTNR: 00465 12; B: 9.600; BOMINFO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; CREATOR: CADENAS GmbH; D: 5.000; D3: 4.019; DK: 10.000; GUETE: 4.8; K: 3.800; L: 12.000; LINA: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; M: 5.300; MATERIAL: ST; NB: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; NBSYN: WUERTH $ARTNR. oval-head screw DIN 7985 $NENN. $GUETE. $OBERFLAECHE.; NN: DIN 7985 (ISO 7045) - 4.8 - zinc-plated (A2K), blue passivated; NT: Cross recessed raised cheese head screws; OBERFLAECHE: A2K; P: 0.800; R: 0.400; RF: 10.000; ROWDESC: M5x12; SUPPLIER: WUERTH; X: 2.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name | Material
3 x DVSA2S-A06_10400.00055.0173A_Default | Stahl
DVSA2S-A06_10400.00055.0173A_Default

# IfcBuildingElementProxy: DVSA2S-A06_10400.00055.0183A (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: 1.0226 (DX51D); Dicke: "Dicke@Blech"; Weight: 0.011; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0001A (6)
In: Default Storey
SolidWorks Custom Properties - BEZEICHNUNG: Blindniete 4,8 x 10,0mm; Description: Blindniete 4,8 x 10,0mm; Material: Stahl verzinkt/Stahl verzinkt, blau passiviert; Dicke: -; Weight: 0.000; Bezeichnung2: Klemmbereich: 4.0 - 6.0 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0002A (90)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Stahl verzinkt/Stahl verzinkt, blau passiviert; Dicke: -; Weight: 0.001; Bezeichnung: Blindniet 3,0 x 6,0; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0003A (5)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Blindniete 4.0 x 8.0 mm; Bezeichnung2: Klemmbereich: 2.5-4.5 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0019A (40)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Becher-Blindniete 4.0 x 8.0 mm; Bezeichnung2: Klemmbereich: 0.5 - 3.5 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0021A (16)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.001; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0028A (18)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: Aluminium/Edelstahl A2; Dicke: -; Weight: 0.000; Bezeichnung: Becher-Blindniet; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0029A (4)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0041A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.003; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0043A_gepresst
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.011; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0044A (38)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0052A (4)
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.00100.0058A (4)
In: Default Storey
SolidWorks Custom Properties - Description: RIVKLE® Einnietmutter M5; Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.01000.0002A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Perspex (TM) GS Acrylic Cast Sheet; Dicke: -; Weight: 0.001; Bezeichnung: Sicherungsstopfen; Bezeichnung2: Bohrungen d=8 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.01020.0001A_1 (3)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.015; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.01020.0001A_2 (3)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.013; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10400.01020.0001A_3 (3)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10500.00100.0005A_Ventilatortragblech A5-10
In: Default Storey
SolidWorks Custom Properties - Material: Gummi; Dicke: "Dicke@Blech1"; Weight: 0.015; Bezeichnung: Abdichtband; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10500.00140.0047A (8)
In: Default Storey
SolidWorks Custom Properties - Description: Teildichtring für Enddeckel DN200; Material: XAC 33; Dicke: "Dicke@Blech1"; Weight: 0.001; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10500.00140.0049A (4)
In: Default Storey
SolidWorks Custom Properties - Material: XAC 33; Dicke: "Dicke@Blech1"; Weight: 0.001; Bezeichnung: Teildichtring; Bezeichnung2: Rohranschluss-Stutzen; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10500.00140.0063A_195.3 (5)
In: Default Storey
SolidWorks Custom Properties - Material: EPDM; Dicke: -; Weight: 0.020; Bezeichnung: Dreilippendichtung; Bezeichnung2: Ø 200; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
4 x DVSA2S-A06_10500.00140.0063A_195.3
DVSA2S-A06_10500.00140.0063A_195.3 | Material: EPDM

# IfcBuildingElementProxy: DVSA2S-A06_10500.00140.0071A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Hauptwarengruppe: Konstruktion; Unterwarengruppe: Dämmstoffzuschnitte; Länge: "Länge@Skizze1"; Breite: "Breite@Skizze1"; Höhe: -; Material: XAC 33; Dicke: 4; Weight: 0.000; Zuschnittlänge: "Länge@Skizze1"; Zuschnittbreite: "Breite@Skizze1"; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA2S-A06_10600.00120.0042A (4)
In: Default Storey
SolidWorks Custom Properties - Material: DX51D+Z o.ä.; Dicke: "Dicke@Blech1"; Weight: 0.211; Bezeichnung: Bundkragen Ø 200 mm innen; Bezeichnung2: L=48 mm; surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_00200.03015.0024C (2)
In: Default Storey
SolidWorks Custom Properties - Material: -; surface: -; Bezeichnung: Enddeckel; Bezeichnung2: DN 200; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_00200.03015.0029B
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_00200.90100.1204G_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Description: Deckel mit Sockelaufsatz für VDR.FDSH; MATERIAL: Aluminiumblech; -------------: AERECO; Weight: 2.841; Bezeichnung: Deckel mit Sockelaufsatz; Bezeichnung2: VDR.FDSH / VDR.SDSHL / VDR.SDSHK; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_00200.90100.1278E_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Description: Flachdachsockel für VDR.FDSH; Weight: 10.552; Bezeichnung: Flachsachsockrl; Bezeichnung2: VDR.FDSH.DVV0.4DN200; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_00200.90100.1297B
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Bezeichnung: Klemmring für Rohranschluss-Stutzen; Bezeichnung2: DN 200; weight: 0.581; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_02020.20211.0002D_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Bezeichnung: DV - A06; Weight: 5.612; Material: -; Surface: -; ProjectNumber: 10149; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_02020.20470.0018B
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_10200.00100.0099B
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 29.10.2021; LastSaveName: wehnes; Material: -; Dicke: -; Weight: 0.038; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_10200.08000.0040A
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_10400.01020.0001A_180° (3)
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Weight: 0.030; Bezeichnung: Scharnier; Bezeichnung2: 50 x 40 x 1.2, gebohrt; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA2S-A06_2x3
In: Default Storey
SolidWorks Custom Properties - Durchmesser Rohranschluss mm: 200; Druckerhöhung zur Auslegung Pa: 130; Maximaler Volumenstrom zur Auslegung (75 %) m3/h: 293; Schalldruckpegel in 3 Meter Entfernung zur Auslegung (75 %) - Lp,A dB(A): 44; Schallleistungspegel an der Saugseite zur Auslegung (75 %) - Lw, A dB(A): 37; Maximaler Volumenstrom (100 %) m3/h: 390; Schalldruckpegel in 3 Meter Entfernung (100 %) - Lp,A dB(A): 48; Schallleistungspegel an der Saugseite (100 %) - Lw, A dB(A): 41; Schalldruckpegel in 3 Meter Entfernung (50 %) - Lp,A dB(A): 41; Schallleistungspegel an der Saugseite (50 %) - Lw, A dB(A): 33; Digitale Druckregelanzeige: -; Einstellbare Druckerhöhung Pa: 40 - 200**; Antriebstechnik: EC-Motor; Reparaturschalter: -; Anschlussspannung: 230 V / 50 Hz; Maximaler Nennstrom A: 0,75; Leistungsaufnahme zur Auslegung (75 %) W: 28; SFP zur Auslegung (75 %) W/m³/h: 0,096; Maximale Leistungsaufnahme (Motoranlauf) Watt: 87; Maximale Lufttemperatur °C: 40; Schutzart des Motors IP: 54; Motorschutz: intern; Störmeldung: -; herausnehmbare Schalldämmungskulisse: standard; Wärmebrückenfreie Konstruktion (S=50 mm, WLG 035): standard; Gewicht des Gerätes (Sockel) kg: 41 (32); Material (Gehäuse): verzinktes Stahlblech, Aluminium (Sockel)
PSet_Mass_Property - Mass Measure: 22.062; Area Measure: 10.3022 m2; Volume Measure: 0.00942943 m3
